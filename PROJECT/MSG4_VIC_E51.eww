<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\MSG4_VIC_E51.ewp</path>
    </project>
    <batchBuild />
</workspace>
