# IAR project MSG4_VIC_E51.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAME51J19A Atmel ATSAME51J19A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: __SAME51J19__
  ICCARM.CCIncludePath2: ..\SOURCE\COMMON; ..\SOURCE\ENTRY_POINT; ..\SOURCE\PLATFORM; ..\SOURCE\PLATFORM\COMPONENTS\BT43; ..\SOURCE\PLATFORM\COMPONENTS\STN; ..\SOURCE\PLATFORM\DEVICE\LINKER; ..\SOURCE\PLATFORM\DEVICE\STARTUP; ..\SOURCE\PLATFORM\DRIVERS\ADC; ..\SOURCE\PLATFORM\DRIVERS\CAN; ..\SOURCE\PLATFORM\DRIVERS\CLOCK; ..\SOURCE\PLATFORM\DRIVERS\CLOCK\GCLK; ..\SOURCE\PLATFORM\DRIVERS\CLOCK\MCLK; ..\SOURCE\PLATFORM\DRIVERS\CLOCK\OSC32KCTRL; ..\SOURCE\PLATFORM\DRIVERS\CLOCK\OSCCTRL; ..\SOURCE\PLATFORM\DRIVERS\EIC; ..\SOURCE\PLATFORM\DRIVERS\GPIO; ..\SOURCE\PLATFORM\DRIVERS\NVIC; ..\SOURCE\PLATFORM\DRIVERS\NVMCTRL; ..\SOURCE\PLATFORM\DRIVERS\SPI; ..\SOURCE\PLATFORM\DRIVERS\TC; ..\SOURCE\PLATFORM\DRIVERS\TCC; ..\SOURCE\PLATFORM\DRIVERS\UART; ..\SOURCE\PLATFORM\DRIVERS\WDT; ..\SOURCE\SERVICES\CAN_IF; ..\SOURCE\APPLICATION\MSG4_APP; ..\SOURCE\APPLICATION\MSG4_APP\AUTHENTICATION; ..\SOURCE\APPLICATION\MSG4_APP\BOOTUP; ..\SOURCE\APPLICATION\MSG4_APP\DIAGNOSTICS; ..\SOURCE\SERVICES\ISO15765_2_TP; ..\SOURCE\PLATFORM\DRIVERS\SYSTICK; ..\SOURCE\APPLICATION\MSG4_APP\PASSTHRU; ..\SOURCE\PLATFORM\COMPONENTS\ADC_SCOPE; ..\SOURCE\APPLICATION\MSG4_APP\ERROR; ..\SOURCE\APPLICATION\MSG4_APP\IDLE; ..\SOURCE\APPLICATION\MSG4_APP\IGN_OFF; ..\SOURCE\APPLICATION\MSG4_APP\IGN_ON; ..\SOURCE\PLATFORM\COMPONENTS\LSM6DSM; ..\SOURCE\TEOBD2; ..\SOURCE\TEOBD2\ISOTPQ; ..\SOURCE\TEOBD2\TEOBD2_STATES\ISO14230_FAST; ..\SOURCE\TEOBD2\TEOBD2_STATES\ISO15765_CAN11B250KBPS; ..\SOURCE\TEOBD2\TEOBD2_STATES\ISO15765_CAN11B500KBPS; ..\SOURCE\TEOBD2\TEOBD2_STATES\ISO15765_CAN29B250KBPS; ..\SOURCE\TEOBD2\TEOBD2_STATES\ISO15765_CAN29B500KBPS; ..\SOURCE\TEOBD2\TEOBD2_STATES\SAEJ1939_CAN29B250KBPS; ..\SOURCE\TEOBD2\XTP; ..\SOURCE\TEOBD2\XTP\XTP_CAN; ..\SOURCE\TEOBD2\XTP\XTP_GE; ..\SOURCE\TEOBD2\XTP\XTP_ISO; ..\SOURCE\TEOBD2\XTP\XTP_OBD; ..\SOURCE\TEOBD2\XTP\XTP_PM; ..\SOURCE\TEOBD2\XTP\XTP_PP; ..\SOURCE\TEOBD2\XTP\XTP_SAEJ1939; ..\SOURCE\TEOBD2\XTP\XTP_TE; ..\SOURCE\SERVICES\ISO14230_TP; ..\SOURCE\SERVICES\SAEJ1939_21_TP; ..\SOURCE\PLATFORM\COMPONENTS\W25QF128JV; ..\SOURCE\PLATFORM\COMPONENTS\HOST_SPISlaveIF; ..\SOURCE\SERVICES\DES_LIB; ..\SOURCE\SERVICES\MD5; ..\SOURCE\SERVICES\MODEM_IF; ..\SOURCE\SERVICES\TBUS
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MSG4_VIC_E51.srec
  ILINK.IlinkOutputFile: MSG4_VIC_E51.out
  ILINK.IlinkIcfFile: ..\SOURCE\PLATFORM\DEVICE\LINKER\same51x19_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group SOURCE/APPLICATION/MSG4_APP
    ../SOURCE/APPLICATION/MSG4_APP/: MSG4_App.c MSG4_App.h MSG4_App_Priv.h
  group SOURCE/APPLICATION/MSG4_APP/AUTHENTICATION
    ../SOURCE/APPLICATION/MSG4_APP/AUTHENTICATION/: AUTHENTICATION.c AUTHENTICATION.h AUTHENTICATION_Priv.h
  group SOURCE/APPLICATION/MSG4_APP/BOOTUP
    ../SOURCE/APPLICATION/MSG4_APP/BOOTUP/: BOOTUP.c BOOTUP.h BOOTUP_Priv.h
  group SOURCE/APPLICATION/MSG4_APP/ERROR
    ../SOURCE/APPLICATION/MSG4_APP/ERROR/: ERROR.c ERROR.h ERROR_Priv.h
  group SOURCE/APPLICATION/MSG4_APP/IDLE
    ../SOURCE/APPLICATION/MSG4_APP/IDLE/: IDLE.c IDLE.h IDLE_Priv.h
  group SOURCE/APPLICATION/MSG4_APP/IGN_OFF
    ../SOURCE/APPLICATION/MSG4_APP/IGN_OFF/: IGN_OFF.c IGN_OFF.h IGN_OFF_Priv.h
  group SOURCE/APPLICATION/MSG4_APP/IGN_ON
    ../SOURCE/APPLICATION/MSG4_APP/IGN_ON/: IGN_ON.c IGN_ON.h IGN_ON_Priv.h
  group SOURCE/APPLICATION/MSG4_APP/PASSTHRU
    ../SOURCE/APPLICATION/MSG4_APP/PASSTHRU/: PASSTHRU.c PASSTHRU.h PASSTHRU_Priv.h
  group SOURCE/COMMON
    ../SOURCE/COMMON/: DATACONV.c DATACONV.h Includes.h
  group SOURCE/ENTRY_POINT
    ../SOURCE/ENTRY_POINT/: ENTRY_POINT.c
  group SOURCE/PLATFORM
    ../SOURCE/PLATFORM/: PLATFORM.c PLATFORM.h PLATFORM_Priv.h
  group SOURCE/PLATFORM/COMPONENTS/ADC_SCOPE
    ../SOURCE/PLATFORM/COMPONENTS/ADC_SCOPE/: ADC_SCOPE.c ADC_SCOPE.h ADC_SCOPE_Priv.h
  group SOURCE/PLATFORM/COMPONENTS/BT43
    ../SOURCE/PLATFORM/COMPONENTS/BT43/: BT43.c BT43.h BT43_Priv.h
  group SOURCE/PLATFORM/COMPONENTS/HOST_SPISlaveIF
    ../SOURCE/PLATFORM/COMPONENTS/HOST_SPISlaveIF/: HOST_SPISlaveIF.c HOST_SPISlaveIF.h HOST_SPISlaveIF_Priv.h
  group SOURCE/PLATFORM/COMPONENTS/LSM6DSM
    ../SOURCE/PLATFORM/COMPONENTS/LSM6DSM/: LSM6DSM.c LSM6DSM.h LSM6DSM_Priv.h
  group SOURCE/PLATFORM/COMPONENTS/STN
    ../SOURCE/PLATFORM/COMPONENTS/STN/: STN.c STN.h STN_Priv.h
  group SOURCE/PLATFORM/COMPONENTS/W25QF128JV
    ../SOURCE/PLATFORM/COMPONENTS/W25QF128JV/: W25QF128JV.c W25QF128JV.h W25QF128JV_Priv.h
  group SOURCE/PLATFORM/DEVICE/LINKER
    ../SOURCE/PLATFORM/DEVICE/LINKER/: same51x19_flash.icf
  group SOURCE/PLATFORM/DEVICE/STARTUP
    ../SOURCE/PLATFORM/DEVICE/STARTUP/: cmsis_compiler.h compiler.h core_cm4.h same51.h same51j19a.h startup_same51.c system_same51.c system_same51.h
  group SOURCE/PLATFORM/DRIVERS/ADC
    ../SOURCE/PLATFORM/DRIVERS/ADC/: ADC.c ADC.h ADC_Priv.h
  group SOURCE/PLATFORM/DRIVERS/CAN
    ../SOURCE/PLATFORM/DRIVERS/CAN/: CAN.c CAN.h CAN_Priv.h
  group SOURCE/PLATFORM/DRIVERS/CLOCK
    ../SOURCE/PLATFORM/DRIVERS/CLOCK/: CLOCK.c CLOCK.h CLOCK_Priv.h
  group SOURCE/PLATFORM/DRIVERS/CLOCK/GCLK
    ../SOURCE/PLATFORM/DRIVERS/CLOCK/GCLK/: GCLK.c GCLK.h GCLK_Priv.h
  group SOURCE/PLATFORM/DRIVERS/CLOCK/MCLK
    ../SOURCE/PLATFORM/DRIVERS/CLOCK/MCLK/: MCLK.c MCLK.h MCLK_Priv.h
  group SOURCE/PLATFORM/DRIVERS/CLOCK/OSC32KCTRL
    ../SOURCE/PLATFORM/DRIVERS/CLOCK/OSC32KCTRL/: OSC32KCTRL.c OSC32KCTRL.h OSC32KCTRL_Priv.h
  group SOURCE/PLATFORM/DRIVERS/CLOCK/OSCCTRL
    ../SOURCE/PLATFORM/DRIVERS/CLOCK/OSCCTRL/: OSCCTRL.c OSCCTRL.h OSCCTRL_Priv.h
  group SOURCE/PLATFORM/DRIVERS/EIC
    ../SOURCE/PLATFORM/DRIVERS/EIC/: EIC.c EIC.h EIC_Priv.h
  group SOURCE/PLATFORM/DRIVERS/GPIO
    ../SOURCE/PLATFORM/DRIVERS/GPIO/: GPIO.c GPIO.h GPIO_Priv.h
  group SOURCE/PLATFORM/DRIVERS/NVIC
    ../SOURCE/PLATFORM/DRIVERS/NVIC/: NVIC.c NVIC.h NVIC_Priv.h
  group SOURCE/PLATFORM/DRIVERS/NVMCTRL
    ../SOURCE/PLATFORM/DRIVERS/NVMCTRL/: NVMCTRL.c NVMCTRL.h NVMCTRL_Priv.h
  group SOURCE/PLATFORM/DRIVERS/SPI
    ../SOURCE/PLATFORM/DRIVERS/SPI/: SPI.c SPI.h SPI_Priv.h
  group SOURCE/PLATFORM/DRIVERS/SYSTICK
    ../SOURCE/PLATFORM/DRIVERS/SYSTICK/: SYSTICK.c SYSTICK.h SYSTICK_Priv.h
  group SOURCE/PLATFORM/DRIVERS/TC
    ../SOURCE/PLATFORM/DRIVERS/TC/: TC.c TC.h TC_Priv.h
  group SOURCE/PLATFORM/DRIVERS/TCC
    ../SOURCE/PLATFORM/DRIVERS/TCC/: TCC.c TCC.h TCC_Priv.h
  group SOURCE/PLATFORM/DRIVERS/UART
    ../SOURCE/PLATFORM/DRIVERS/UART/: UART.c UART.h UART_Priv.h
  group SOURCE/PLATFORM/DRIVERS/WDT
    ../SOURCE/PLATFORM/DRIVERS/WDT/: WDT.c WDT.h WDT_Priv.h
  group SOURCE/SERVICES/CAN_IF
    ../SOURCE/SERVICES/CAN_IF/: CAN_IF.c CAN_IF.h CAN_IF_Priv.h
  group SOURCE/SERVICES/DES_LIB
    ../SOURCE/SERVICES/DES_LIB/: DES.c DES.h
  group SOURCE/SERVICES/ISO14230_TP
    ../SOURCE/SERVICES/ISO14230_TP/: ISOTP14230_TP.c ISOTP14230_TP_private.h ISOTP14230_TP_public.h
  group SOURCE/SERVICES/ISO15765_2_TP
    ../SOURCE/SERVICES/ISO15765_2_TP/: ISO15765_2.c ISO15765_2.h ISO15765_2_Priv.h
  group SOURCE/SERVICES/MD5
    ../SOURCE/SERVICES/MD5/: MD5.c MD5.h MD5_Priv.h
  group SOURCE/SERVICES/SAEJ1939_21_TP
    ../SOURCE/SERVICES/SAEJ1939_21_TP/: SAEJ1939_21_TP.c SAEJ1939_21_TP_private.h SAEJ1939_21_TP_public.h
  group SOURCE/SERVICES/TBUS
    ../SOURCE/SERVICES/TBUS/: TBUS.c TBUS.h TBUS_Priv.h
  group SOURCE/TEOBD2
    ../SOURCE/TEOBD2/: TEOBD2.c TEOBD2_private.h TEOBD2_public.h
  group SOURCE/TEOBD2/ISOTPQ
    ../SOURCE/TEOBD2/ISOTPQ/: ISOTPQ.c ISOTPQ_private.h ISOTPQ_public.h
  group SOURCE/TEOBD2/TEOBD2_STATES/ISO14230_FAST
    ../SOURCE/TEOBD2/TEOBD2_STATES/ISO14230_FAST/: ISO14230_FAST.c ISO14230_FAST_private.h ISO14230_FAST_public.h
  group SOURCE/TEOBD2/TEOBD2_STATES/ISO15765_CAN11B250KBPS
    ../SOURCE/TEOBD2/TEOBD2_STATES/ISO15765_CAN11B250KBPS/: ISO15765_CAN11B250KBPS.c ISO15765_CAN11B250KBPS_private.h ISO15765_CAN11B250KBPS_public.h
  group SOURCE/TEOBD2/TEOBD2_STATES/ISO15765_CAN11B500KBPS
    ../SOURCE/TEOBD2/TEOBD2_STATES/ISO15765_CAN11B500KBPS/: ISO15765_CAN11B500KBPS.c ISO15765_CAN11B500KBPS_private.h ISO15765_CAN11B500KBPS_public.h
  group SOURCE/TEOBD2/TEOBD2_STATES/ISO15765_CAN29B250KBPS
    ../SOURCE/TEOBD2/TEOBD2_STATES/ISO15765_CAN29B250KBPS/: ISO15765_CAN29B250KBPS.c ISO15765_CAN29B250KBPS_private.h ISO15765_CAN29B250KBPS_public.h
  group SOURCE/TEOBD2/TEOBD2_STATES/ISO15765_CAN29B500KBPS
    ../SOURCE/TEOBD2/TEOBD2_STATES/ISO15765_CAN29B500KBPS/: ISO15765_CAN29B500KBPS.c ISO15765_CAN29B500KBPS_private.h ISO15765_CAN29B500KBPS_public.h
  group SOURCE/TEOBD2/TEOBD2_STATES/SAEJ1939_CAN29B250KBPS
    ../SOURCE/TEOBD2/TEOBD2_STATES/SAEJ1939_CAN29B250KBPS/: SAEJ1939_CAN29B250KBPS.c SAEJ1939_CAN29B250KBPS_private.h SAEJ1939_CAN29B250KBPS_public.h
  group SOURCE/TEOBD2/XTP
    ../SOURCE/TEOBD2/XTP/: XTP.c XTP_private.h XTP_public.h
  group SOURCE/TEOBD2/XTP/XTP_CAN
    ../SOURCE/TEOBD2/XTP/XTP_CAN/: XTP_CAN.c XTP_CAN_private.h XTP_CAN_public.h
  group SOURCE/TEOBD2/XTP/XTP_GE
    ../SOURCE/TEOBD2/XTP/XTP_GE/: XTP_GE.c XTP_GE_private.h XTP_GE_public.h
  group SOURCE/TEOBD2/XTP/XTP_ISO
    ../SOURCE/TEOBD2/XTP/XTP_ISO/: XTP_ISO.c XTP_ISO_private.h XTP_ISO_public.h
  group SOURCE/TEOBD2/XTP/XTP_OBD
    ../SOURCE/TEOBD2/XTP/XTP_OBD/: XTP_OBD.c XTP_OBD_private.h XTP_OBD_public.h
  group SOURCE/TEOBD2/XTP/XTP_PM
    ../SOURCE/TEOBD2/XTP/XTP_PM/: XTP_PM.c XTP_PM_private.h XTP_PM_public.h
  group SOURCE/TEOBD2/XTP/XTP_PP
    ../SOURCE/TEOBD2/XTP/XTP_PP/: XTP_PP.c XTP_PP_private.h XTP_PP_public.h
  group SOURCE/TEOBD2/XTP/XTP_SAEJ1939
    ../SOURCE/TEOBD2/XTP/XTP_SAEJ1939/: XTP_SAEJ1939.c XTP_SAEJ1939_private.h XTP_SAEJ1939_public.h
  group SOURCE/TEOBD2/XTP/XTP_TE
    ../SOURCE/TEOBD2/XTP/XTP_TE/: XTP_TE.c XTP_TE_private.h XTP_TE_public.h
